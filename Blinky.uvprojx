# Keil uVision project Blinky.uvprojx, settings and files
target SAML11Xpro (6230000::V6.23::ARMCLANG)
  device: ATSAML11E16A Microchip
  pack: Microchip.SAML11_DFP.4.5.268
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) IROM2(0x00400000,0x800) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x400000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.2.0, Device:Startup 4.5.0
